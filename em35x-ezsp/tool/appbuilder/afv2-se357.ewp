# IAR project afv2-se357.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: EMBER_SERIAL1_TX_QUEUE_SIZE=_replace_serial1TxQueueSize_; EMBER_SERIAL1_RX_QUEUE_SIZE=_replace_serial1RxQueueSize_; EMBER_SERIAL0_TX_QUEUE_SIZE=_replace_serial0TxQueueSize_; EMBER_SERIAL0_RX_QUEUE_SIZE=_replace_serial0RxQueueSize_; GENERATED_TOKEN_HEADER="app/builder/_replace_projectName_/_replace_tokenHeader_"; ZA_GENERATED_HEADER="app/builder/_replace_projectName_/_replace_projectName_.h"; _replace_bootloader_; BOARD_HEADER="_replace_boardHeader_"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/_replace_projectName_/_replace_projectName__endpoint_config.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: EMBER_SERIAL1_TX_QUEUE_SIZE=_replace_serial1TxQueueSize_; EMBER_SERIAL1_RX_QUEUE_SIZE=_replace_serial1RxQueueSize_; EMBER_SERIAL0_TX_QUEUE_SIZE=_replace_serial0TxQueueSize_; EMBER_SERIAL0_RX_QUEUE_SIZE=_replace_serial0RxQueueSize_; GENERATED_TOKEN_HEADER="app/builder/_replace_projectName_/_replace_tokenHeader_"; ZA_GENERATED_HEADER="app/builder/_replace_projectName_/_replace_projectName_.h"; _replace_bootloader_; BOARD_HEADER="_replace_boardHeader_"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/_replace_projectName_/_replace_projectName__endpoint_config.h"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: _replace_projectName_.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: _replace_projectName_.out
  ILINK.IlinkConfigDefines: _replace_bootloader_=1
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em357/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/: adc.c bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c button.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c sleep.c token-def.c token.c uart.c
    ../../../app/framework/util/: af-eeprom.c af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c fragmentation.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c util.c
    ../../../app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../app/framework/gen/: call-command-handler.c callback-stub.c stack-handler-stub.c
    ../../../app/util/serial/: command-interpreter2.c serial.c
    ../../../app/util/concentrator/: concentrator.c
    ../../../app/util/counters/: counters.c
    ../../../hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../hal/: ember-configuration.c
    ../../../app/util/common/: form-and-join-node-adapter.c form-and-join-node-callbacks.c form-and-join.c library.c
    ../../../build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../../hal/micro/cortexm3/em35x/: mpu.c
    ../../../app/framework/cli/: core-cli.c network-cli.c plugin-cli.c security-cli.c ota-cli-client.c ota-cli-common.c ota-cli-server.c zcl-cli.c zdo-cli.c
    ../../../app/framework/report/: report-table.c
    ../../../app/util/security/: security-address-cache.c
    ../../../app/util/: source-route-common.c source-route.c
    ../../../app/util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
