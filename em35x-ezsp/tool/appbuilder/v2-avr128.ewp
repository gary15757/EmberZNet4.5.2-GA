# IAR project v2-avr128.ewp, settings and files
configuration AppFramework-avr128 (AVR)
  General.LCHeapSize: 0
  General.SCCStackSize: 0x300
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: PLATFORM_HEADER="hal/micro/avr-atmega/compiler/iar.h"; BOARD_DEV0473; PHY_NULL; EMBER_SERIAL0_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL0_TX_QUEUE_SIZE=128; EMBER_SERIAL0_RX_QUEUE_SIZE=16; AVR_ATMEGA; AVR_ATMEGA_128; EZSP_HOST; BOARD_HEADER="hal/micro/avr-atmega/128/board/dev0473.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; ZA_GENERATED_HEADER="app/builder/_replace_projectName_/_replace_projectName_.h"; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/_replace_projectName_/_replace_projectName__endpoint_config.h"; __SOURCEFILE__="$FILE_FNAME$"; APP_SERIAL=0
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.IExtraOptions: --string_literals_in_flash
  ICCAVR.newCCIncludePaths: ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  postbuild: "..\..\..\tool\etrim\etrim.exe"  "$TARGET_DIR$\$TARGET_FNAME$" -c 128L
  XLINK.XclFile: ..\..\..\hal\micro\avr-atmega\128\app-cfg.xcl
  XLINK.XExtraOptions: -y(CODE) -w6
  group app/framework/cli
    ../../framework/cli/: core-cli.c network-cli.c ota-cli-client.c ota-cli-common.c ota-cli-server.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
  group app/framework/gen
    ../../framework/gen/: callback-stub.c stack-handler-stub.c call-command-handler.c
  group app/framework/report
    ../../framework/report/: report-table.c
  group app/framework/security
    ../../framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
  group app/framework/util
    ../../framework/util/: af-main-host.c af-main-common.c af-eeprom.c af-event.c af-event-host.c attribute-size.c attribute-storage.c attribute-table.c fragmentation.c print.c client-api.c message.c process-cluster-message.c process-global-message.c service-discovery-host.c service-discovery-common.c util.c
  group app/util
    ../../util/: source-route-common.c source-route-host.c
  group app/util/common
    ../../util/common/: library.c form-and-join.c form-and-join-host-adapter.c form-and-join-host-callbacks.c
  group app/util/concentrator
    ../../util/concentrator/: concentrator.c
  group app/util/ezsp
    ../../util/ezsp/: ezsp-callbacks.c ezsp-frame-utilities.c ezsp.c serial-interface-spi.c
  group app/util/serial
    ../../util/serial/: command-interpreter2.c serial.c
  group app/util/zigbee-framework
    ../../util/zigbee-framework/: zigbee-device-common.c zigbee-device-host.c
  group Hal/micro/avr-atmega
    ../../../hal/micro/avr-atmega/: adc.c button.c buzzer.c led.c spi-protocol.c spi.c uart.c
  group Hal/micro/avr-atmega/128
    ../../../hal/micro/avr-atmega/128/: cstartup.s90 low-level-init.c micro.c system-timer.c
  group Hal/micro/generic
    ../../../hal/micro/generic/: crc.c mem-util.c random.c
