# IAR project v2-stm32f103ret.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: AF_SPI_HOST; BOARD_HEADER="hal/host/cortexm3/stm32f103ret/null.h"; PLATFORM_HEADER="hal/host/cortexm3/stm32f103ret/compiler/iar-st.h"; HAL_HOST; STM32F10X_HD; USE_STDPERIPH_DRIVER; EMBER_SERIAL_USE_STDIO; CONFIGURATION_HEADER="app/framework/util/config.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=128; EZSP_HOST; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/_replace_projectName_/_replace_projectName__endpoint_config.h"; ZA_GENERATED_HEADER="app/builder/_replace_projectName_/_replace_projectName_.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCOptLevel: 3
  ICCARM.CCIncludePath2: $FILE_DIR$; ../../..; ../../../stack; ../../../hal; ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport; ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../../../hal/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/inc; ../../.././hal/host/cortexm3/stm32f103ret; ../../.././hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport; ../../.././hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../../.././hal/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: AF_SPI_HOST; BOARD_HEADER="hal/host/cortexm3/stm32f103ret/null.h"; PLATFORM_HEADER="hal/host/cortexm3/stm32f103ret/compiler/iar-st.h"; HAL_HOST; STM32F10X_HD; USE_STDPERIPH_DRIVER; EMBER_SERIAL_USE_STDIO; CONFIGURATION_HEADER="app/framework/util/config.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=128; EZSP_HOST; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/_replace_projectName_/_replace_projectName__endpoint_config.h"; ZA_GENERATED_HEADER="app/builder/_replace_projectName_/_replace_projectName_.h"
  AARM.AUserIncludes: $FILE_DIR$; ../../..; ../../../stack; ../../../hal; ../../../host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport; ../../../host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../../../host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/inc; ../../.././hal/host/cortexm3/stm32f103ret; ../../.././hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport; ../../.././hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../../.././hal/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/inc
  OBJCOPY.OOCOutputFile: _replace_projectName_.s37
  ILINK.IlinkOutputFile: _replace_projectName_.out
  ILINK.IlinkIcfFile: ../../../hal/host/cortexm3/stm32f103ret/iar-cfg-st.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../hal/host/cortexm3/stm32f103ret/: adc.c button.c buzzer.c led.c micro.c spi-protocol.c system-timer.c uart.c
    ../../../app/framework/util/: af-event-host.c af-eeprom.c af-event.c af-main-common.c af-main-host.c attribute-size.c attribute-storage.c attribute-table.c client-api.c fragmentation.c message.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-host.c util.c
    ../../../app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../app/framework/gen/: call-command-handler.c callback-stub.c stack-handler-stub.c
    ../../../app/util/serial/: command-interpreter2.c serial.c
    ../../../app/util/concentrator/: concentrator.c
    ../../../app/framework/cli/: core-cli.c network-cli.c ota-cli-client.c ota-cli-common.c ota-cli-server.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../hal/host/generic/: crc.c
    ../../../app/util/ezsp/: ezsp-callbacks.c ezsp-frame-utilities.c ezsp.c serial-interface-spi.c
    ../../../app/util/common/: form-and-join-host-adapter.c form-and-join-host-callbacks.c form-and-join.c library.c
    ../../../app/util/gateway/: gateway-stub.c
    ../../../hal/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../../app/framework/report/: report-table.c
    ../../../app/util/: source-route-common.c source-route-host.c
    ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../../../hal/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../app/util/zigbee-framework/: zigbee-device-common.c zigbee-device-host.c
